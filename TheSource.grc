options:
  parameters:
    author: jackh
    generate_options: qt_gui
    id: thesource
    output_language: python
    title: the Source
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Num_Samples_To_Count: '32000'
    _source_code: "import numpy as np\r\nfrom gnuradio import gr\r\nimport pmt\r\nclass blk(gr.sync_block):\r\n    def __init__(self, Num_Samples_To_Count =128):\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name='Selector Control',\r\n            in_sig=[np.complex64],\r\n            out_sig=[np.complex64]\r\n        )\r\n        self.Num_Samples_To_Count = Num_Samples_To_Count\r\n        self.portName='messageOutput'\r\n        self.message_port_register_out(pmt.intern(self.portName))\r\n        self.state=True\r\n        self.counter = 0\r\n\r\n    def work(self, input_items, output_items):\r\n        self.counter = self.counter + len(output_items[0])\r\n        if(self.counter > self.Num_Samples_To_Count):\r\n            PMT_msg = pmt.from_bool(self.state)\r\n            self.message_port_pub(pmt.intern(self.portName), PMT_msg)\r\n            self.state = not(self.state)\r\n            self.counter = 0\r\n        output_items[0][:] = input_items[0]\r\n        return len(output_items[0])\r\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Multiplexer',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selectPortName = 'selectPort'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.selector=True

          def handle_msg(self,msg):
              self.selector=pmt.to_bool(msg)
             

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if (self.selector):
                  output_items[0][:] = input_items[0]
              else:
                  output_items[0][:] = input_items[1]

              return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', epy_block_1, '0']
- [analog_sig_source_x_1, '0', epy_block_1, '1']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, messageOutput, blocks_message_debug_0, print]
- [epy_block_0, messageOutput, epy_block_1, selectPort]
- [epy_block_1, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
